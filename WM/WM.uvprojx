# Keil uVision project WM.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WM
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Drivers\STM32F3xx_HAL_Driver\Inc\;.;.\GPIO\Inc
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Src
    ./Src/: WM.cpp device_layer.cpp device_layer.h hardwarelayer_map.h
    ./: gpio_7seg_setup.h
  group HAL
    ./Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal_msp.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal.c stm32f3xx_hal_cortex.c
  group GPIO
    ./GPIO/Src/: stm32f3xx_it.c gpio_setup.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.0.0
